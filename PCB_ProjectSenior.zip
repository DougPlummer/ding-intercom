# Altium project PCB_ProjectSenior.PrjPcb
2 sheets, 0 parts. Net scope: global (net labels, ports and power ports of the same name join across sheets).
Sheets:
  POWER_PI.SchDoc
  CODEC_INTERFACE.SchDoc

## Sheet POWER_PI.SchDoc
size A; SheetNumber: 1; SheetTotal: 1

## Sheet CODEC_INTERFACE.SchDoc
size A; SheetNumber: 2; SheetTotal: 2